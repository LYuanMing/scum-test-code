# Keil uVision project channel_cal.uvprojx, settings and files
target channel_cal (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(10000000) ELITTLE
  output: channel_cal +hex
  AfterMake: fromelf --bin .\Objects\channel_cal.axf -o .\Objects\channel_cal.bin
  AfterMake: fromelf -cvf .\Objects\channel_cal.axf -o .\Objects\disasm.txt
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ../../
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group app
    ./: channel_cal.c channel_cal_main.c channel_cal.h
  group drv
    ../../: cm0dsasm.s Memory_Map.h retarget.c optical.c optical.h radio.c radio.h adc.c adc.h gpio.c gpio.h uart.c uart.h rftimer.c rftimer.h scum_defs.h scm3c_hw_interface.h scm3c_hw_interface.c ieee_802_15_4.h ieee_802_15_4.c tuning.c tuning.h
