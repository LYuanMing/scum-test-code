# Keil uVision project inter_calibration.uvprojx, settings and files
target inter_calibration (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: inter_calibration +hex
  AfterMake: fromelf --bin .\Objects\inter_calibration.axf -o .\Objects\inter_calibration.bin
  AfterMake: fromelf -cvf .\Objects\inter_calibration.axf -o .\Objects\disasm.txt
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\self_calibration;..\..\..\scm_v3c
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group app
    ./: freq_setting_selection.c freq_setting_selection.h inter_calibration.c
  group drv
    ../../: adc.c adc.h cm0dsasm.s gpio.c gpio.h memory_map.h optical.c optical.h radio.c radio.h retarget.c rftimer.c rftimer.h scm3c_hw_interface.c scm3c_hw_interface.h scum_defs.h uart.c uart.h
